Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[DesignTransferView]
File name: /dev/null
Time: 2026-09-22T14:18:55+00:00
Written by: IfcOpenShell 0.8.5
Made in: IfcOpenShell 0.8.5
Authorization: Nobody

# IfcFurnishingElement: Оборудование благоустройства, ZSK-205-0611 Тематическая фигура (Животные) «Синий Кит»
In: Площадка
Description: Оборудование благоустройства. Тематическая фигура (Животные) «Синий Кит»; Material: Нержавеющая сталь, атмосферостойкий HDPE, армированные канат
Pset_ManufacturerTypeInformation - Manufacturer: Завод современных конструкций (ЗСК) · ООО «ПКФ «ОРИОН» · зск.рф · sales@zavod-orion.ru · 8 (351) 214-80-80; ModelLabel: ZSK-205-0611; ModelReference: Тематическая фигура (Животные) «Синий Кит»; ProductionYear: 2026; ArticleNumber: ZSK-205-0611
ORION_Изделие - Артикул: ZSK-205-0611; Артикул прежний: SD-205-0611; Наименование: Тематическая фигура (Животные) «Синий Кит»; Изготовитель: ООО «ПКФ «ОРИОН»; Марка: Завод современных конструкций (ЗСК); Город: Миасс, Челябинская область; Габариты: 6.7 x 4.9 м; Зона безопасности: 9.70 x 7.90 м; Высота свободного падения: 1.2 м; Возраст: для детей от 2 до 12 лет; Материал: Нержавеющая сталь, атмосферостойкий HDPE, армированные канаты; Цена: 5 700 000 ₽; Нормативы: ГОСТ Р 52169-2012, ГОСТ Р 52301-2013; Карточка изделия: https://зск.рф/catalog/animals/308; Код КСИ: CPr>EDFB; Класс КСИ: Скульптуры; Коды КСР: …
ADSK - ADSK_Наименование: Тематическая фигура (Животные) «Синий Кит»; ADSK_Марка: ZSK-205-0611; ADSK_Код изделия: ZSK-205-0611; ADSK_Завод-изготовитель: ООО «ПКФ «ОРИОН»; ADSK_Единица измерения: шт.; ADSK_Количество: 1; ADSK_Обозначение: ГОСТ Р 52169-2012, ГОСТ Р 52301-2013; ADSK_Материал: Нержавеющая сталь, атмосферостойкий HDPE, армированные канаты; ADSK_URL страницы изделия: https://зск.рф/catalog/animals/308
ZSK_Благоустройство - ZSK_Возрастная_группа: для детей от 2 до 12 лет; ZSK_Зона_безопасности: 9.70 x 7.90 м; ZSK_Высота_свободного_падения: 1.2 м; ZSK_Нормативы: ГОСТ Р 52169-2012, ГОСТ Р 52301-2013; ZSK_Код_КСИ: CPr>EDFB; ZSK_Артикул_прежний: SD-205-0611
Qto_ORION - Длина: 6700 mm; Ширина: 4900 mm; Высота: 0 mm
